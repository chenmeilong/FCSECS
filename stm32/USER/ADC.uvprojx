# Keil uVision project ADC.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\IIC;..\HARDWARE\WDG;..\HARDWARE\CCS;..\HARDWARE\USART2;..\HARDWARE\ESP8266;..\HARDWARE\OTHERS;..\HARDWARE\TIMER;..\HARDWARE\DHT22
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/IIC/: IIC.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/CCS/: CCS.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/OTHERS/: others.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DHT22/: dht22.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_wwdg.c stm32f10x_iwdg.c stm32f10x_dma.c stm32f10x_tim.c
  group README
    ../: README.TXT
